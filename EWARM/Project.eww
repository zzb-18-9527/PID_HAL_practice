<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PID_HAL.ewp</path>
  </project>
  <batchBuild />
</workspace>
